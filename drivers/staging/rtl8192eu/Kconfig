## drivers/staging/rtl8192eu/Kconfig
```kconfig
config RTL8192EU
	tristate "Realtek 8192EU USB WiFi"
	depends on USB
	---help---
	  Help message of RTL8192EU
```
